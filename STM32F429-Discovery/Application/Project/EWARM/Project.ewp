# IAR project Project.ewp, settings and files
configuration STM32F429-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM32F429I_DISCO; HSE_VALUE=8000000; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_FREE_RTOS=1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\CMSIS\Include; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\STM32F429I-Discovery; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\Components\Common; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\Components\ili9341; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\Components\stmpe811; ..\..\Source; ..\..\..\TargetSpecific; ..\..\GeneratedCode; ..\..\..\PlatformPackage\RTE; ..\..\GeneratedCode\EmWiGfxInclude; ..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\include; ..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-STM32F429-Discovery.hex
  ILINK.IlinkOutputFile: EmbeddedWizard-STM32F429-Discovery.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c main.c
    ./: startup_stm32f429xx.s
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_system.c ew_bsp_touch.c stm32f4xx_it.c system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/ili9341/: ili9341.c
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM32F429I_Discovery
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: Application.c Core.c Effects.c Graphics.c Resources.c Views.c
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: ewextgfx.c libewgfx-m4-iar.a
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewextrte.c libewrte-m4-iar.a
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
